Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-04-12T23:24:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 12 23:24:18 2023 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\1617cc4e-74d7-4cc6-b778-424f551224ef\6ee94a6a-8f58-4525-ad3c-1b0c02726c81\ifc * Database version: 5507 * Database creation date: Wed Apr 12 23:24:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 12 23:24:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 12 23:24:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFurnishingElement: ACX Mesh, Vitra-Office_and_Conference_Chairs-ACX-Mesh_rfa:ACX Mesh:8872
In: Level 1
Type - Material: Black (textured), Deep black powder-coated, Avocado, Petrol/Nero
Type - Constraints - Default Elevation: 0 mm
Type - General - Author: BIMstone; BIMObjectName: Vitra-Office_and_Conference_Chairs-ACX-Mesh_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Designed by Ronan and Erwan Bouroullec, the Softshell Chair mounted on a height-adjustable five-star swivel base with castors is ideal for studio offices. Its contours and quality materials give it an inviting appeal, while the soft upholstery guarantees superb comfort.; Revision: 0; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: ACX; Cost: 0; Description: Thanks to its automatic synchronised mechanism, the compact task chair ACX provides instant ergonomic comfort for users of different sizes – without them having to adjust anything except the seat height. The necessary functions and operating elements are carefully integrated in the chair's construction, whose clean lines convey an inviting understated aesthetic. The construction, materials, production, logistics and maintenance of ACX are designed to achieve a long life cycle with the smallest possible carbon footprint.; Designer: Antonio Citterio; Manufacturer: Vitra; Model: ACX Mesh; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: ACX Mesh
Type - Materials and Finishes - Armrestcushion material: Black (textured)
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Office_and_Conference_Chairs-ACX-Mesh_rfa; Features: synchronised mechanism with automatic weight adjustment and two backrest resistance settings (hard or soft). Equipped as standard with seat height and seat depth adjustment. Optionally available with or without synchronised forward tilt (can be disengaged). Mechanism can be locked in upright sitting position. Seat mechanism matches the frame colour (deep black or soft grey).; Finish: n/a; Grade: n/a; ModelNumber: n/a; ModelReference: 43300200; Name: ACX-Mesh_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 495x550x995 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Construction - armrest: height-ajustable armrest; formfit seat F: yes; Lumbar suport: yes; Mechanism with forward tilt with seat depth adjustment: no; Mechanism without forward tilt with seat depth adjustment: yes; standard seat: no
Dimensions - Area: 1.87822 m2; Volume: 0.485564 m3
Materials and Finishes - Backrest colour: Petrol/Nero; Base On: Black (textured); Frame colour: Deep black powder-coated; Seat colour: Avocado
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Office_and_Conference_Chairs-ACX-Mesh_rfa: ACX Mesh; Family and Type: Vitra-Office_and_Conference_Chairs-ACX-Mesh_rfa: ACX Mesh; InstallationDate: n/a; Material: Metal, Textile and Plastic; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Office_and_Conference_Chairs-ACX-Mesh_rfa: ACX Mesh; Type Id: Vitra-Office_and_Conference_Chairs-ACX-Mesh_rfa: ACX Mesh; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
